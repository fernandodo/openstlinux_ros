FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-OP-TEE-Enable-non-secure-access-for-USART6-RIF.patch"

