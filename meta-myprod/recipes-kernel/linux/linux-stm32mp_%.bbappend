FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Enable-USART6-on-stm32mp257f-dk.patch"
