FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Enable-USART6-for-A35-Core-RIFSC-DTS.patch"

