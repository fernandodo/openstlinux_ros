# Local wrapper to align with generated-recipes version
require ../../../layers/meta-ros/meta-ros2-jazzy/generated-recipes/fuse/fuse-tutorials_1.1.3-1.bb
