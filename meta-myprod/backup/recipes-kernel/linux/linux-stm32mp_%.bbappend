FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI:append = " file://lttng.cfg"
